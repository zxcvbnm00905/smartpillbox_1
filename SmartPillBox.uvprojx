# Keil uVision project SmartPillBox.uvprojx, settings and files
target SmartPillBox (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: SmartPillBox +hex
  c flags: uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\USER;.\BSP;.\APP;.\Libraries\CMSIS;.\Libraries\Device;.\Libraries\StdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c stm32f10x_it.c
  group BSP
    ./BSP/: bsp_lcd.c bsp_touch.c bsp_rtc.c bsp_led.c bsp_beep.c bsp_key.c bsp_ir.c
  group APP
    ./APP/: pillbox.c gui.c
  group StdPeriph
    ./Libraries/StdPeriph/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c
  group Device
    ./Libraries/StdPeriph/src/: stm32f10x_exti.c
    ./Libraries/Device/: startup_stm32f10x_hd.s system_stm32f10x.c
